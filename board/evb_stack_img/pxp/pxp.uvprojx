# Keil uVision project pxp.uvprojx, settings and files
target pxp (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: app +hex
  BeforeMake: ..\..\..\tool\before_build_common.bat $K
  BeforeMake: before_build_special.bat
  AfterMake: ..\..\..\tool\after_build_common.bat $J #L @L
  AfterMake: after_build_special.bat
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: SUPPORT_ALONE_UPPERSTACK_IMG
  c misc: --gnu --preinclude app_flags.h --bss_threshold=0
  c include: ..\..\..\bin\upperstack_img\upperstack_0_0;..\..\..\inc\app;..\..\..\inc\bluetooth\gap;..\..\..\inc\bluetooth\gap\gap_lib;..\..\..\inc\bluetooth\profile;..\..\..\inc\bluetooth\profile\server;..\..\..\inc\bluetooth\profile\client;..\..\..\inc\os;..\..\..\inc\peripheral;..\..\..\inc\platform;..\..\..\src\app\pxp;..\pxp
  asm misc: --cpreproc
  asm include: ..\..\..\inc\platform
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\app.sct
  link misc: --diag_suppress=L6314,L6312 --datacompressor off
  group include
    ../../../inc/platform/: rom_uuid.h app_define.h
  group lib
    ../../../bin/: ROM.lib sbee2_sdk.lib
    ../../../bin/upperstack_img/upperstack_0_0/: gap_utils.lib
  group cmsis
    ../../../src/mcu/rtl876x/arm/: startup_rtl876x.s
    ../../../src/mcu/rtl876x/: system_rtl876x.c
  group peripheral
    ../../../src/mcu/peripheral/: rtl876x_io_dlps.c rtl876x_nvic.c rtl876x_pinmux.c rtl876x_aon_wdg.c rtl876x_gpio.c rtl876x_rcc.c rtl876x_tim.c
  group profile
    ../../../src/ble/profile/server/: bas.c dis.c ias.c lls.c tps.c
    ../../../src/app/pxp/: kns.c
  group app
    ../../../src/mcu/rtl876x/: overlay_mgr.c
    ../../../src/app/pxp/: app_task.c iohandle.c main.c pxp_app.c reset_watch_dog_timer.c
