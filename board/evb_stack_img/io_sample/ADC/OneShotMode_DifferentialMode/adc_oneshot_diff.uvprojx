# Keil uVision project adc_oneshot_diff.uvprojx, settings and files
target demo (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: app
  BeforeMake: before_build_special.bat
  AfterMake: ..\..\tool\after_build_common.bat $J #L @L
  AfterMake: after_build_special.bat
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: SUPPORT_ALONE_UPPERSTACK_IMG
  c misc: --gnu --preinclude app_flags.h --bss_threshold=0
  c include: ..\..\..\..\..\bin\upperstack_img\upperstack_0_0;..\..\..\..\..\inc\app;..\..\..\..\..\inc\bluetooth\gap;..\..\..\..\..\inc\bluetooth\gap\gap_lib;..\..\..\..\..\inc\bluetooth\profile;..\..\..\..\..\inc\bluetooth\profile\server;..\..\..\..\..\inc\bluetooth\profile\client;..\..\..\..\..\inc\os;..\..\..\..\..\inc\peripheral;..\..\..\..\..\inc\platform;..\..\..\..\..\inc\platform\cmsis;.\;..\..\..\..\..\src\sample\io_sample\ADC\OneShotMode_DifferentialMode;..\..\..\..\..\src\sample\io_sample\ADC\OneShotMode_DifferentialMode\ble_peripheral
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\app.sct
  link misc: --diag_suppress=L6314,L6312 --datacompressor off
  group include
    ../../../../../inc/platform/: app_define.h rom_uuid.h
  group lib
    ../../../../../bin/: adc.lib ROM.lib
    ../../../../../bin/upperstack_img/upperstack_0_0/: gap_utils.lib
  group cmsis
    ../../../../../src/mcu/rtl876x/arm/: startup_rtl876x.s
    ../../../../../src/mcu/rtl876x/: system_rtl876x.c overlay_mgr.c
  group peripheral
    ../../../../../src/mcu/peripheral/: rtl876x_adc.c rtl876x_nvic.c rtl876x_pinmux.c rtl876x_rcc.c rtl876x_tim.c
  group profile
    ../../../../../src/ble/profile/client/: ancs_client.c
    ../../../../../src/ble/profile/server/: bas.c simple_ble_service.c
  group app
    ../../../../../src/sample/io_sample/ADC/OneShotMode_DifferentialMode/ble_peripheral/: main.c app.c app_task.c ancs.c
    ../../../../../src/sample/io_sample/ADC/OneShotMode_DifferentialMode/: io_adc.c
